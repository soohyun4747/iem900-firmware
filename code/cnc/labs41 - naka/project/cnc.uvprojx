# Keil uVision project cnc.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F205ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cnc +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F2XX, SYSCLK_FREQ_120MHz
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../src/: main.c stm32f2xx_it.c delay.c adc_input.c graphic.c touch_i2c.c fsmc_lcd.c rtc_calender.c buzzer.c error.c voc_filter_chrck.c
  group Chamber
    ../src/: door_com.c pid_control.c temp_ic_spi.c timer_pwm.c chamber_work.c device.c
  group RS232_Com
    ../src/: control_uart.c
  group Usb_out
    ../src/: usb_out.c FILE_SYS.C SPI_HW.C
  group Data_save
    ../src/: fsmc_nand.c data_io.c
  group STM32F2xx_StdPeriph_Driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_gpio.c stm32f2xx_tim.c stm32f2xx_rcc.c stm32f2xx_fsmc.c stm32f2xx_usart.c stm32f2xx_iwdg.c stm32f2xx_dma.c stm32f2xx_spi.c stm32f2xx_i2c.c stm32f2xx_adc.c stm32f2xx_rtc.c stm32f2xx_pwr.c misc.c
  group CMSIS
    ../../../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
software components: CMSIS:CORE 5.0.0
